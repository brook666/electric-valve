<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>fwlib</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\..\FWlib\inc\stm8l15x.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\inc\stm8l15x_clk.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\inc\stm8l15x_dma.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\inc\stm8l15x_exti.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\inc\stm8l15x_flash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\inc\stm8l15x_gpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\inc\stm8l15x_irtim.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\inc\stm8l15x_iwdg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\inc\stm8l15x_pwr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\inc\stm8l15x_rst.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\inc\stm8l15x_rtc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\inc\stm8l15x_syscfg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\inc\stm8l15x_tim2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\inc\stm8l15x_usart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\inc\stm8l15x_wwdg.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\FWlib\src\stm8l15x_clk.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\src\stm8l15x_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\src\stm8l15x_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\src\stm8l15x_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\src\stm8l15x_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\src\stm8l15x_irtim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\src\stm8l15x_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\src\stm8l15x_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\src\stm8l15x_rst.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\src\stm8l15x_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\src\stm8l15x_syscfg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\src\stm8l15x_tim2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\src\stm8l15x_usart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\src\stm8l15x_wwdg.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>user</name>
    <file>
      <name>$PROJ_DIR$\..\USER\dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\stm8l15x_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\stm8l15x_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\sysclock.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\timer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USER\uart1.c</name>
    </file>
  </group>
</project>


