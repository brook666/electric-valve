# IAR project electric valve.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L051F3 STM8L051F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: USE_STDPERIPH_DRIVER; STM8L15X_MD
  ICCSTM8.CCIncludePath2: ..\FWlib\inc; ..\FWlib\src; ..\USER
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: electric valve.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group fwlib/inc
    ../FWlib/inc/: stm8l15x.h stm8l15x_clk.h stm8l15x_dma.h stm8l15x_exti.h stm8l15x_flash.h stm8l15x_gpio.h stm8l15x_irtim.h stm8l15x_iwdg.h stm8l15x_pwr.h stm8l15x_rst.h stm8l15x_rtc.h stm8l15x_syscfg.h stm8l15x_tim2.h stm8l15x_usart.h stm8l15x_wwdg.h
  group fwlib/src
    ../FWlib/src/: stm8l15x_clk.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_irtim.c stm8l15x_iwdg.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_syscfg.c stm8l15x_tim2.c stm8l15x_usart.c stm8l15x_wwdg.c
  group user
    ../USER/: dma.c main.c stm8l15x_conf.h stm8l15x_it.c sysclock.c timer.c uart1.c
